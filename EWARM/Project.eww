<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RM2020_Wandering.ewp</path>
  </project>
  <batchBuild />
</workspace>
